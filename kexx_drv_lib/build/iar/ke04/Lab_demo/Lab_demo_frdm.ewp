# IAR project Lab_demo_frdm.ewp, settings and files
configuration FLASH_8KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MKE04Z8xxx4 Freescale MKE04Z8xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FRDM_KE04; CPU_KE04
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\src\projects\ke04\Lab_demo; ..\..\..\..\src\projects\ke04\Lab_demo\accelerometer_test; ..\..\..\..\src\projects\ke04\Lab_demo\angle_calculation; ..\..\..\..\src\projects\ke04\Lab_demo\TSS; ..\..\..\..\src\common; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu\headers; ..\..\..\..\src\drivers\acmp; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\crc; ..\..\..\..\src\drivers\ftm; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\ics; ..\..\..\..\src\drivers\iic; ..\..\..\..\src\drivers\kbi; ..\..\..\..\src\drivers\nvm; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\wdog; ..\..\..\..\src\drivers\pwt; ..\..\..\..\src\drivers\can; ..\..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab_demo_frdm.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\KE0x_Flash_8K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h systick.c systick.h vectors.c vectors.h
  group cpu/headers
    ../../../../src/cpu/headers/: MKE04Z4.h
  group drivers/ACMP
    ../../../../src/drivers/acmp/: acmp.c acmp.h
  group drivers/ADC
    ../../../../src/drivers/adc/: adc.c adc.h
  group drivers/BME
    ../../../../src/drivers/bme/: BME.h
  group drivers/CRC
    ../../../../src/drivers/crc/: crc.c crc.h
  group drivers/FTM
    ../../../../src/drivers/ftm/: ftm.h
  group drivers/GPIO
    ../../../../src/drivers/gpio/: gpio.h
  group drivers/ICS
    ../../../../src/drivers/ics/: ics.c ics.h
  group drivers/IIC
    ../../../../src/drivers/iic/: i2c.c i2c.h
  group drivers/KBI
    ../../../../src/drivers/kbi/: kbi.c kbi.h
  group drivers/NVM
    ../../../../src/drivers/nvm/: flash.c flash.h
  group drivers/PIT
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/PMC
    ../../../../src/drivers/PMC/: pmc.c pmc.h
  group drivers/RTC
    ../../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/SIM
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/SPI
    ../../../../src/drivers/spi/: spi.h
  group drivers/UART
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/WDOG
    ../../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: KE0x_Flash_32K.icf KE0x_Flash_64K.icf KE0x_Flash_64K_bootloaderApp.icf KE0x_Flash_64K_EEPROM_256.icf KE0x_Flash_64K_FlashConfig.icf KE0x_RAM_4KB.icf
  group platforms
    ../../../../src/platforms/: ke04_config.h
  group project
    ../../../../src/projects/KE04/Lab_demo/: irda.c irda.h isr.h Lab_demo.c Led.c Led.h
  group project/accelerometer_test
    ../../../../src/projects/KE04/Lab_demo/accelerometer_test/: hal_dev_mma8451.c hal_dev_mma8451.h mma8451_test.c mma8451_test.h
  group project/angle_calculation
    ../../../../src/projects/KE04/Lab_demo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h median.c median.h sqrt16.c sqrt16.h
