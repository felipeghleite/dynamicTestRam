<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CAN_Node1WithInt_demo_frdm.ewp</path>
  </project>
  <batchBuild/>
</workspace>


