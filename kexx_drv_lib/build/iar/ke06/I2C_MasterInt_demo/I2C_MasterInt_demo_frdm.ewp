# IAR project I2C_MasterInt_demo_frdm.ewp, settings and files
configuration RAM_16KB (ARM, debug)
  General.OGChipSelectEditMenu: MKE06Z128xxx4 Freescale MKE06Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FRDM_KE06; CPU_KE06
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\src\projects\ke06\I2C_MasterInt_demo; ..\..\..\..\src\common; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu\headers; ..\..\..\..\src\drivers\acmp; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\bitband; ..\..\..\..\src\drivers\crc; ..\..\..\..\src\drivers\ftm; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\ics; ..\..\..\..\src\drivers\iic; ..\..\..\..\src\drivers\kbi; ..\..\..\..\src\drivers\nvm; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\wdog; ..\..\..\..\src\drivers\pwt; ..\..\..\..\src\drivers\can; ..\..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_MasterInt_demo_frdm.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\KE0x_RAM_16KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB_PFLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: pa082,pa050
  ILINK.IlinkIcfFile: ..\config files\KE0x_Flash_128K.icf
  group common
    ../../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h systick.c systick.h vectors.c vectors.h
  group cpu/headers
    ../../../../src/cpu/headers/: MKE06Z4.h
  group drivers
    ../../../../src/drivers/can/: mscan.c mscan.h
  group drivers/ACMP
    ../../../../src/drivers/acmp/: acmp.c acmp.h
  group drivers/BitBand
    ../../../../src/drivers/bitband/: bitband.h
  group drivers/CRC
    ../../../../src/drivers/crc/: crc.c crc.h
  group drivers/I2C
    ../../../../src/drivers/iic/: i2c.c i2c.h
  group drivers/ICS
    ../../../../src/drivers/ics/: ics.c ics.h
  group drivers/PIT
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/PWT
    ../../../../src/drivers/pwt/: pwt.c pwt.h
  group drivers/RTC
    ../../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/SIM
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/SPI
    ../../../../src/drivers/spi/: spi.c spi.h
  group drivers/UART
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/WDOG
    ../../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: KE0x_Flash_32K.icf KE0x_Flash_64K.icf KE0x_Flash_64K_bootloaderApp.icf KE0x_Flash_64K_EEPROM_256.icf KE0x_Flash_64K_FlashConfig.icf KE0x_RAM_4KB.icf
  group platforms
    ../../../../src/platforms/: ke06_config.h
  group project
    ../../../../src/projects/KE06/I2C_MasterInt_demo/: i2c_app.c i2c_app.h I2C_MasterInt_demo.c isr.h
