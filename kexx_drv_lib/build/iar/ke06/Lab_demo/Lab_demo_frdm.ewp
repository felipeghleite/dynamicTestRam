# IAR project Lab_demo_frdm.ewp, settings and files
configuration RAM_16KB (ARM, debug)
  General.OGChipSelectEditMenu: MKE02Z64xxx2 Freescale MKE02Z64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FRDM_KE06; CPU_KE06
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\src\projects\ke06\Lab_demo; ..\..\..\..\src\projects\ke06\Lab_demo\accelerometer_test; ..\..\..\..\src\projects\ke06\Lab_demo\angle_calculation; ..\..\..\..\src\common; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu\headers; ..\..\..\..\src\drivers\acmp; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\crc; ..\..\..\..\src\drivers\ftm; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\ics; ..\..\..\..\src\drivers\iic; ..\..\..\..\src\drivers\kbi; ..\..\..\..\src\drivers\nvm; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\wdog; ..\..\..\..\src\drivers\pwt; ..\..\..\..\src\drivers\can; ..\..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab_demo_frdm.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\KE0x_RAM_16KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB_PFLASH (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKE06Z128xxx4 Freescale MKE06Z128xxx4
  ICCARM.CCDiagSuppress: Pa050
  ILINK.IlinkIcfFile: ..\config files\KE0x_Flash_128K.icf
  group common
    ../../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h systick.c systick.h vectors.c vectors.h
  group cpu/headers
    ../../../../src/cpu/headers/: MKE06Z4.h
  group drivers/FTM
    ../../../../src/drivers/ftm/: ftm.c ftm.h
  group drivers/I2C
    ../../../../src/drivers/iic/: i2c.c i2c.h
  group drivers/ICS
    ../../../../src/drivers/ics/: ics.c ics.h
  group drivers/KBI
    ../../../../src/drivers/kbi/: kbi.c kbi.h
  group drivers/PIT
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/RTC
    ../../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/SIM
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/UART
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/WDOG
    ../../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: KE0x_Flash_32K.icf KE0x_Flash_64K.icf KE0x_Flash_64K_bootloaderApp.icf KE0x_Flash_64K_EEPROM_256.icf KE0x_Flash_64K_FlashConfig.icf KE0x_RAM_4KB.icf
  group platforms
    ../../../../src/platforms/: ke06_config.h
  group project
    ../../../../src/projects/KE06/Lab_demo/: irda.c irda.h isr.h Key.c Key.h Lab_demo.c Led.c Led.h
  group project/accelerometer_test
    ../../../../src/projects/KE06/Lab_demo/accelerometer_test/: hal_dev_mma8451.c hal_dev_mma8451.h mma8451_test.c mma8451_test.h
  group project/angle_calculation
    ../../../../src/projects/KE06/Lab_demo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h median.c median.h sqrt16.c sqrt16.h
