# Keil uVision project GPIO_OneCycleAccess_demo.uvproj, settings and files
target KE02Z-Flash (ARM-ADS)
  device: MKE02Z64xxx2 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: GPIO_OneCycleAccess_demo_Flash
  AfterMake: fromelf --m32combined --output=outfile.s19  GPIO_OneCycleAccess_demo_Flash.axf
  c define: KEIL FRDM_KE02  CPU_KE02 CMSIS
  c misc: --c99
  c include: ..\..\..\..\src\projects\ke02\GPIO_OneCycleAccess_demo;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\acmp;..\..\..\..\src\platforms;..\..;..\..\..\..\src\drivers\ics;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\wdog;..\..\..\..\src\drivers\ftm;..\..\..\..\src\drivers\nvm;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\kbi;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\crc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\iic;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\PMC;..\..\..\..\src\drivers\adc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group project
    ../../../../src/projects/KE02/GPIO_OneCycleAccess_demo/: GPIO_OneCycleAccess_demo.c
  group common
    ../../../../src/common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../../src/cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_MKE02Z2.s
  group drivers
    ../../../../src/drivers/acmp/: acmp.c
    ../../../../src/drivers/adc/: adc.c
    ../../../../src/drivers/crc/: crc.c
    ../../../../src/drivers/ftm/: ftm.c
    ../../../../src/drivers/gpio/: gpio.c
    ../../../../src/drivers/ics/: ics.c
    ../../../../src/drivers/iic/: i2c.c
    ../../../../src/drivers/kbi/: kbi.c
    ../../../../src/drivers/nvm/: flash.c
    ../../../../src/drivers/pit/: pit.c
    ../../../../src/drivers/PMC/: pmc.c
    ../../../../src/drivers/rtc/: rtc.c
    ../../../../src/drivers/sim/: sim.c
    ../../../../src/drivers/spi/: spi.c
    ../../../../src/drivers/uart/: uart.c
    ../../../../src/drivers/wdog/: wdog.c
