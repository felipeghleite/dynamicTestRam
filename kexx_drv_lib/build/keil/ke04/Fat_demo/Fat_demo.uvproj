# Keil uVision project Fat_demo.uvproj, settings and files
target KE04Z-Flash (ARM-ADS)
  device: MKE04Z8xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFF00-0x1FFFFFFF) IRAM2(0x20000000-0x200002FF) IROM(0x0-0x1FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Fat_demo_Flash
  c flags: Optim=3
  c define: KEIL FRDM_KE04  CPU_KE04 CMSIS
  c include: ..\..\..\..\src\projects\ke04\Fat_demo;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\acmp;..\..\..\..\src\platforms;..\..;..\..\..\..\src\drivers\ics;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\wdog;..\..\..\..\src\drivers\ftm;..\..\..\..\src\drivers\nvm;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\kbi;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\crc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\iic;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\PMC;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\pwt;..\..\..\..\src\drivers\bitband;..\..\..\..\src\projects\ke04\Lab_demo;..\..\..\..\src\projects\ke04\Lab_demo\accelerometer_test;..\..\..\..\src\projects\ke04\Lab_demo\angle_calculation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x1fffff00 size 0x100
  memory RVCT10: RAM 0x20000000 size 0x300
  group project
    ../../../../src/projects/KE04/Fat_demo/: Fat_demo.c
    ../../../../src/projects/KE04/Lab_demo/: irda.c Led.c
    ../../../../src/projects/KE04/Lab_demo/angle_calculation/: angle_cal.c asin.c median.c sqrt16.c
    ../../../../src/projects/KE04/Lab_demo/accelerometer_test/: hal_dev_mma8451.c mma8451_test.c
  group common
    ../../../../src/common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../../src/cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_MKE04Z4.s
  group drivers
    ../../../../src/drivers/acmp/: acmp.c
    ../../../../src/drivers/adc/: adc.c
    ../../../../src/drivers/crc/: crc.c
    ../../../../src/drivers/ftm/: ftm.c
    ../../../../src/drivers/gpio/: gpio.c
    ../../../../src/drivers/ics/: ics.c
    ../../../../src/drivers/iic/: i2c.c
    ../../../../src/drivers/kbi/: kbi.c
    ../../../../src/drivers/nvm/: flash.c
    ../../../../src/drivers/pit/: pit.c
    ../../../../src/drivers/PMC/: pmc.c
    ../../../../src/drivers/rtc/: rtc.c
    ../../../../src/drivers/sim/: sim.c
    ../../../../src/drivers/spi/: spi.c
    ../../../../src/drivers/uart/: uart.c
    ../../../../src/drivers/wdog/: wdog.c
    ../../../../src/drivers/pwt/: pwt.c
